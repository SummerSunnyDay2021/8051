# Keil uVision project key_debounce.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: key_debounce +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: key_debounce.c STARTUP.A51
